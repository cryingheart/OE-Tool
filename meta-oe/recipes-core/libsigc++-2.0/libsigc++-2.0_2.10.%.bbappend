CXXFLAGS_append_sh4 = " -std=gnu++11 "
